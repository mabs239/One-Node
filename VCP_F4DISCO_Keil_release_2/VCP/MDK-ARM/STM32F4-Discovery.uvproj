# Keil uVision project STM32F4-Discovery.uvproj, settings and files
target VCP (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: VCP +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM32F4_DISCOVERY,USE_USB_OTG_FS,HSE_VALUE=8000000
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32F4-Discovery;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: system_stm32f4xx.c stm32f4_discovery.c stm32fxxx_it.c main.c cc1101.c HelperFunctions.c
  group STM32F4xx_StdPeriph_Driver
    ../: usb_core.c
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group MDK-ARM
    ../: startup_stm32f4xx.s
  group STM32_USB_OTG_Driver
    ../: usb_bsp.c usb_dcd.c usb_dcd_int.c
  group STM32_USB_Device_Library
    ../: usbd_core.c usbd_ioreq.c usbd_req.c usbd_usr.c usbd_desc.c usbd_cdc_core.c usbd_cdc_vcp.c
